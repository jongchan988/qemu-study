## source-avr32/hw/jc1904/Kconfig
```kconfig
config JC1904EXP_MCU
    bool

config JC1904EXAMPLE_BOARD
    bool
    select JC1904EXP_MCU
```
